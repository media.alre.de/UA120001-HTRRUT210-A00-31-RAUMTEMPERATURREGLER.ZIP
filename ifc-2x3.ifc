Properties of the parts of a building model (IFC2X3)

# File
Description: Raumtemperaturregler mit Leuchtringskala, UP, Rahmen, Abdeckung 55 x 55 mm, reinweiß, glänzend, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UA120001, Raumtemperaturregler mit Leuchtringskala, UP, Rahmen, Abdeckung 55 x 55 mm, reinweiß, glänzend
In: Raum
Description: Dieser Raumtemperaturregler wurde speziell für die Regelung oder Überwachung von Temperaturen in Büros, Wohnräumen und Hotels entwickelt und ist zum direkten Anschluss von bis zu 10 Ventilantrieben (stromlos geschlossen) für Warmwasserheizungen geeignet. Das Gerät ist mit kreisförmig angeordneten LEDs ausgestattet, die die aktuelle Solltemperatur anzeigen, und ermöglicht es dem Benutzer, die gewünschte Temperatur über einfache Auf-/Ab-Tastsensoren einzustellen.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UA120001; ModelLabel: HTRRUt210.A00#31; GlobalTradeItemNumber: 4050528078179; ProductURL: https://alre.de/produkt_UA120001
Pset_Specification - NominalLength: 0.085 m; NominalWidth: 0.081 m; NominalDepth: 0.0413 m; NetWeight: 0.115
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Farbe: weiß; Breite: 81; Höhe: 85; Tiefe: 41.3; RAL-Nummer: 9010; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Schließer (NO); Messbereich: 17; Bedienung: Taste; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: IV; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Max. Kontaktbelastung: 1; Differenzwert: 0.5; Sensor extern: no; Thermische Rückkopplung: ohne; Geeignet für Heizung: yes; Geeignet für Kühlen: no; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UA120001.pdf
